options:
  parameters:
    author: B. Kerler
    copyright: '2022'
    generate_options: qt_gui
    id: FM_receiver
    output_language: python
    title: FM Radio
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 98.6e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0
    label: Gain
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 3e6
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 120e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 24e3
    win: window.WIN_HAMMING
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: Volume
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.1'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    deemph_tau: '75e-6'
    quad_rate: 192e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume Control
    const: volume
    type: float
  states: {}
- name: blocks_sigmf_source_minimal_0
  id: blocks_sigmf_source_minimal
  parameters:
    repeat: 'True'
    type: complex float (fc32_le)
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: 200e3
    decim: '1'
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_0
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    comment: Just double click on the waterfall to set the frequency
    key: freq
    label: Frequency Offset
    type: double
    value: 98.5e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: freq
    fftsize: '1024'
    gui_hint: 3,0
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 4,0
    showports: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '3000'
    interp: '192'
    type: ccc
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    center_freq0: freq-200e3
    dc_removal0: 'False'
    driver: airspy
    gain0: gain
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_source_0
  id: soapy_source
  parameters:
    balance0: '0'
    center_freq0: freq
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    dev: driver=airspy
    devname: custom
    overall_gain0: '10'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_sigmf_source_minimal_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [qtgui_edit_box_msg_0, msg, blocks_msgpair_to_var_0, inpair]
- [qtgui_waterfall_sink_x_0, freq, qtgui_edit_box_msg_0, val]
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [soapy_custom_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [soapy_custom_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_custom_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [soapy_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [soapy_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-233-ga20232e9
