options:
  parameters:
    author: Mic - YD3BRB
    copyright: Copyleft
    generate_options: qt_gui
    id: HackRFNFBM
    output_language: python
    title: HackRF_RX
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: int(4.8e4)
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '8'
    stop: '40'
    value: '24'
  states: {}
- name: quadrature_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: shift
  id: variable_qtgui_range
  parameters:
    start: '-6e3'
    step: '100'
    stop: 6e3
    value: '3800'
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    start: '-100'
    step: '5'
    stop: '0'
    value: '-50'
  states: {}
- name: tune_freq
  id: variable_qtgui_range
  parameters:
    start: 143e6
    step: 0.5e3
    stop: 149e6
    value: '145600000'
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '2'
    stop: '62'
    value: '28'
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.3'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_samp_rate
    max_dev: 5e3
    quad_rate: int (quadrature_rate)
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: 0.2e3
    decim: '1'
    gain: '1'
    samp_rate: 48e3
    type: fir_filter_fff
    width: '50'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: high_pass_filter_1
  id: high_pass_filter
  parameters:
    cutoff_freq: '200'
    decim: '1'
    gain: '1'
    samp_rate: quadrature_rate
    type: fir_filter_fff
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 9e3
    decim: '1'
    gain: '1'
    samp_rate: quadrature_rate
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/4
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate)
    interp: int(quadrature_rate)
    type: ccc
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: tune_freq-shift
    gain: if_gain
    samp_rate: samp_rate
    type: fc32
    vga: vga_gain
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [blocks_multiply_const_vxx_0, '0', high_pass_filter_1, '0']
- [high_pass_filter_1, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
