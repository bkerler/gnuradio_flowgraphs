options:
  parameters:
    author: B. Kerler
    category: '[Pocsag]'
    copyright: '2022'
    description: Pocsag Decoder
    generate_options: qt_gui
    id: Pocsag_Decoder
    output_language: python
    title: Pocsag Decoder
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: lowp
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 15e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 30e4
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '960000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    deemph_tau: '75e-6'
    quad_rate: 176.4e3
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 8e3
    low_cutoff_freq: '50'
    samp_rate: 22.05e3
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/test
    type: short
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_short_1
  id: blocks_float_to_short
  parameters:
    scale: 300e3
  states: {}
- name: blocks_msgpair_to_var_0_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq
  states: {}
- name: blocks_sigmf_source_minimal_0
  id: blocks_sigmf_source_minimal
  parameters:
    file: sigid.sigmf-data
    repeat: 'True'
    type: complex float (fc32_le)
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: ./data/POCSAG_IQ_2.wav
    nchan: '2'
    repeat: 'True'
  states: {state: disabled}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: freq
    decim: '1'
    samp_rate: samp_rate
    taps: lowp
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '2'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 20e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    comment: |-
      https://github.com/EliasOenal/multimon-ng

      nc -l -u 127.0.0.1 2000 | multimon-ng -t raw -a POCSAG512 -a POCSAG1200 -a POCSAG2400 -a SCOPE -f alpha --timestamp -
    header: '0'
    payloadsize: '1472'
    port: '2000'
    send_eof: 'True'
    type: short
  states: {}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    comment: Just double click on the waterfall to set the frequency
    key: freq
    label: Frequency Offset
    type: double
    value: 0e3
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 22.05e3
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: 22.05e3
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 4,0
    showports: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: int(22.05e3)
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: demod
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: demod
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: demod
  states: {}

connections:
- [analog_wfm_rcv_0, '0', band_pass_filter_0, '0']
- [band_pass_filter_0, '0', blocks_float_to_short_1, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_short_1, '0', blocks_file_sink_0, '0']
- [blocks_float_to_short_1, '0', network_udp_sink_0, '0']
- [blocks_sigmf_source_minimal_0, '0', blocks_throttle_1, '0']
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_throttle_1, '0', freq_xlating_fft_filter_ccc_0, '0']
- [blocks_throttle_1, '0', qtgui_waterfall_sink_x_0_1, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [freq_xlating_fft_filter_ccc_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', virtual_sink_0, '0']
- [qtgui_edit_box_msg_0_0, msg, blocks_msgpair_to_var_0_0, inpair]
- [qtgui_waterfall_sink_x_0_1, freq, qtgui_edit_box_msg_0_0, val]
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_0_0, '0']
- [virtual_source_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-233-ga20232e9
