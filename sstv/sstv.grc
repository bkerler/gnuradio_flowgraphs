options:
  parameters:
    author: B. Kerler
    copyright: '2022'
    description: SSTV Demodulator
    generate_options: qt_gui
    id: sstv
    output_language: python
    title: SSTV + FM Demod
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    outputmsgname: center_freq
    showports: 'True'
    start: freq-1000e3
    step: 10e3
    stop: freq+1000e3
    value: '915000000'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: samp_rate/quadrate
  states: {}
- name: freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.1'
    stop: '4'
    value: '1'
  states: {}
- name: lptap
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 96e3
    gain: '1'
    samp_rate: samp_rate
    width: 48e3
    win: window.WIN_HAMMING
  states: {}
- name: quadrate
  id: variable
  parameters:
    value: 192e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 192e3
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    type: int
    value: '0'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: int(decimation)
    deemph_tau: '75e-6'
    quad_rate: quadrate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: |-
      Create loopback audio device:
      --------------------------------------------------
      pacmd load-module module-null-sink sink_name=VirtualCable
      pacmd update-sink-proplist VirtualCable device.description=VirtualCable
      pacmd load-module module-loopback sink=VirtualCable

      Start qsstv, then run pavucontrol, select "Monitor of Null" for qsstv input
      Press play in qsstv and wait for the picture
    device_name: pulse:VirtualCable
    ok_to_block: 'False'
    samp_rate: int(audio_rate)
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume/100
    type: float
  states: {}
- name: blocks_sigmf_source_minimal_0
  id: blocks_sigmf_source_minimal
  parameters:
    file: /home/bjk/Projects/gnuradio_tutorial/sstv/data/sstv_192000sps_914600000hz_iq.sigmf-data
    repeat: 'False'
    type: complex float (fc32_le)
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: center_freq-freq
    decim: '1'
    samp_rate: samp_rate
    taps: lptap
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 24e3
    decim: int(quadrate/audio_rate)
    gain: gain
    samp_rate: quadrate
    type: fir_filter_fff
    width: 24e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}

connections:
- [analog_wfm_rcv_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_1, '0']
- [blocks_sigmf_source_minimal_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', analog_wfm_rcv_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-233-ga20232e9
