options:
  parameters:
    author: B. Kerler
    copyright: '2022'
    description: SSB Receiver
    generate_options: qt_gui
    id: ssb_rx
    output_language: python
    title: SSB Receiver
  states: {}

blocks:
- name: Frequency
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0
    type: int
    value: int((center_freq+tuner-(2*filter_width))/1e3)
  states: {}
- name: agc_attack
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '1e-1'
    step: '100'
    stop: '3e-1'
    value: '.1'
  states: {}
- name: agc_decay
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '10e-6'
    step: '100'
    stop: '100e-6'
    value: '65e-6'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '1537249117'
  states: {}
- name: decimate
  id: variable
  parameters:
    value: int(samp_rate/25e3)
  states: {}
- name: filter_width
  id: variable
  parameters:
    value: 3e3
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '30000'
    value: '1'
  states: {}
- name: lowtap
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 4e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.024e6
  states: {}
- name: tuner
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: center_freq-512e3
    step: '100'
    stop: center_freq+512e3
    value: '1537100000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.1'
    stop: '1'
    value: '.8'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1'
    max_gain: '65536'
    rate: agc_attack
    reference: '1.0'
    type: complex
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    device_name: pulse:VirtualAudio
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/hydra/inmarsat/baseband_1537249117Hz_18-50-02_22-04-2022.wav
    nchan: '2'
    repeat: 'True'
  states: {state: disabled}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: int(tuner-center_freq)
    decim: decimate
    samp_rate: samp_rate
    taps: lowtap
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: hilbert_fc_0_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: int(48e3)
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: int(48e3)
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/decimate)
    interp: int(48e3)
    type: ccc
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    agc0: 'True'
    center_freq0: center_freq-(filter_width/2)
    dc_removal0: 'False'
    dev_args: remote=tcp://satellite.local:55132
    driver: remote
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [blocks_add_xx_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_float_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_add_xx_1, '0']
- [blocks_complex_to_float_0_0, '0', blocks_add_xx_1, '1']
- [blocks_complex_to_float_0_0, '1', blocks_null_sink_0_0, '0']
- [blocks_complex_to_float_1, '0', hilbert_fc_0_0, '0']
- [blocks_complex_to_float_1, '1', hilbert_fc_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_1, '0']
- [blocks_throttle_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [freq_xlating_fft_filter_ccc_0, '0', rational_resampler_xxx_1, '0']
- [hilbert_fc_0, '0', blocks_complex_to_float_0_0, '0']
- [hilbert_fc_0_0, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_1, '0', blocks_complex_to_float_1, '0']
- [rational_resampler_xxx_1, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_waterfall_sink_x_1, '0']
- [soapy_custom_source_0, '0', analog_agc_xx_0, '0']
- [soapy_custom_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-233-ga20232e9
