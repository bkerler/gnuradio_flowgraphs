options:
  parameters:
    author: B. Kerler
    copyright: '2022'
    description: SSB Receiver
    generate_options: no_gui
    id: ssb_rx
    output_language: python
    title: SSB Receiver
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '1537100000'
  states: {}
- name: decimate
  id: variable
  parameters:
    value: int(samp_rate/25e3)
  states: {}
- name: filter_width
  id: variable
  parameters:
    value: 4e3
  states: {}
- name: gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: lowtap
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 4e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.024e6
  states: {}
- name: tuner
  id: variable
  parameters:
    value: '1537100000'
  states: {}
- name: volume
  id: variable
  parameters:
    value: '0.8'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1'
    max_gain: '65536'
    rate: '100e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    device_name: pulse:VirtualAudio
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: int(tuner-center_freq)
    decim: decimate
    samp_rate: samp_rate
    taps: lowtap
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: hilbert_fc_0_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/decimate)
    interp: int(48e3)
    type: ccc
  states: {}
- name: soapy_custom_source_0_0
  id: soapy_custom_source
  parameters:
    agc0: 'True'
    center_freq0: center_freq-(filter_width/2)
    dc_removal0: 'False'
    dev_args: remote=tcp://satellite.local:55132
    driver: remote
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [blocks_add_xx_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_float_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_add_xx_1, '0']
- [blocks_complex_to_float_0_0, '0', blocks_add_xx_1, '1']
- [blocks_complex_to_float_0_0, '1', blocks_null_sink_0_0, '0']
- [blocks_complex_to_float_1, '0', hilbert_fc_0_0, '0']
- [blocks_complex_to_float_1, '1', hilbert_fc_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_1, '0']
- [freq_xlating_fft_filter_ccc_0, '0', rational_resampler_xxx_1, '0']
- [hilbert_fc_0, '0', blocks_complex_to_float_0_0, '0']
- [hilbert_fc_0_0, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_1, '0', blocks_complex_to_float_1, '0']
- [soapy_custom_source_0_0, '0', analog_agc_xx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-233-ga20232e9
