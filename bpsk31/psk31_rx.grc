options:
  parameters:
    author: argilo
    category: Custom
    comment: https://github.com/argilo/gr-ham
    generate_options: qt_gui
    id: psk31_rx
    output_language: python
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '441800000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: RX gain
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.4'
    stop: '50'
    value: '10'
  states: {}
- name: int_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: psk_center
  id: variable_qtgui_range
  parameters:
    label: Tuning
    outputmsgname: value
    showports: 'False'
    start: center_freq - samp_rate//2
    step: '1000'
    stop: center_freq +samp_rate//2
    value: center_freq + 141000
  states: {}
- name: psk_offset
  id: variable_qtgui_range
  parameters:
    label: PSK offset
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '10'
    stop: '3000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '960000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-3'
    reference: '0.1'
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: int_rate // audio_rate
    gain: '1'
    high_cutoff_freq: '2800'
    low_cutoff_freq: '200'
    samp_rate: int_rate
    type: fir_filter_ccc
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: psk31.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_sigmf_source_minimal_0
  id: blocks_sigmf_source_minimal
  parameters:
    file: /home/bjk/Projects/ctf/SigInt/challenge#1/sigid.sigmf-data
    repeat: 'True'
    type: complex float (fc32_le)
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: '16'
    omega_relative_limit: '0.005'
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 5 * math.pi /100.0
  states: {}
- name: digital_diff_phasor_cc_0
  id: digital_diff_phasor_cc
  parameters: {}
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: round(psk_center - center_freq,-3)
    decim: samp_rate // int_rate
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 12000, 12000, window.WIN_HAMMING, 6.76)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: psk_offset
    decim: '16'
    samp_rate: audio_rate
    taps: firdes.low_pass(10, audio_rate, 120, 40, window.WIN_HAMMING, 6.76)
    type: ccc
  states: {}
- name: ham_varicode_rx_0
  id: ham_varicode_rx
  parameters: {}
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: center_freq
    gain0: gain
    gain_mode0: '0'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate / 120 / 16 / 16
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate / 120
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / 20
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_2
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / 120
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    showports: 'True'
    type: float
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_complex_to_real_0, '0']
- [analog_agc_xx_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [band_pass_filter_0, '0', analog_agc_xx_0, '0']
- [blocks_complex_to_real_0, '0', audio_sink_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_waterfall_sink_x_2, '0']
- [blocks_complex_to_real_1, '0', digital_binary_slicer_fb_0, '0']
- [blocks_sigmf_source_minimal_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_binary_slicer_fb_0, '0', ham_varicode_rx_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_diff_phasor_cc_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_time_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_1, '0']
- [digital_costas_loop_cc_0, '1', qtgui_number_sink_0, '0']
- [digital_diff_phasor_cc_0, '0', blocks_complex_to_real_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', band_pass_filter_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_1, '0', digital_costas_loop_cc_0, '0']
- [ham_varicode_rx_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-233-ga20232e9
