options:
  parameters:
    author: B. Kerler 2022
    category: Custom
    copyright: '2022'
    description: APRS Modulator / Demodulator
    generate_options: qt_gui
    id: aprs_rxtx
    output_language: python
    run_options: run
    title: APRS Modulator / Demodulator
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '960000'
  states: {}
- name: tuner_offset
  id: variable
  parameters:
    value: '-200e3'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_rate
    max_dev: 5e3
    quad_rate: audio_rate
    tau: '75e-6'
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: audio_rate
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: float
  states: {state: disabled}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2*math.pi*-tuner_offset/samp_rate
  states: {state: disabled}
- name: blocks_sigmf_source_minimal_0
  id: blocks_sigmf_source_minimal
  parameters:
    file: sigid.sigmf-data
    repeat: 'True'
    type: complex float (fc32_le)
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: audio_rate
    type: float
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: ./data/aprs.wav
    repeat: 'True'
  states: {}
- name: bruninga_ax25_fsk_mod_0
  id: bruninga_ax25_fsk_mod
  parameters:
    baud_rate: '1200'
    flag_count: '10'
    mark_freq: '2200'
    preamble_len_ms: '300'
    samp_rate: audio_rate
    space_freq: '1200'
  states: {state: disabled}
- name: bruninga_fsk_demod_0
  id: bruninga_fsk_demod
  parameters:
    samp_rate: audio_rate
  states: {}
- name: bruninga_str_to_aprs_0
  id: bruninga_str_to_aprs
  parameters:
    dest: NOCALL
    src: NOCALL
    via: '[]'
  states: {state: disabled}
- name: digital_hdlc_deframer_bp_0
  id: digital_hdlc_deframer_bp
  parameters:
    max: '500'
    min: '15'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '8000'
    decim: '20'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    comment: Modulation
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    type: fff
  states: {}

connections:
- [analog_nbfm_rx_0, '0', bruninga_fsk_demod_0, '0']
- [analog_nbfm_rx_0, '0', qtgui_sink_x_1, '0']
- [audio_source_0, '0', bruninga_fsk_demod_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_rotator_cc_0, '0', low_pass_filter_0, '0']
- [blocks_sigmf_source_minimal_0, '0', blocks_throttle_1, '0']
- [blocks_throttle_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle_1, '0', blocks_rotator_cc_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [bruninga_ax25_fsk_mod_0, '0', blocks_multiply_const_vxx_0, '0']
- [bruninga_fsk_demod_0, '0', digital_hdlc_deframer_bp_0, '0']
- [bruninga_str_to_aprs_0, out, bruninga_ax25_fsk_mod_0, in]
- [digital_hdlc_deframer_bp_0, out, blocks_message_debug_0, print]
- [digital_hdlc_deframer_bp_0, out, blocks_message_debug_0, print_pdu]
- [low_pass_filter_0, '0', analog_nbfm_rx_0, '0']
- [network_socket_pdu_0, pdus, bruninga_str_to_aprs_0, in]
- [rational_resampler_xxx_0, '0', bruninga_fsk_demod_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-233-ga20232e9
