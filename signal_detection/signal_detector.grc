options:
  parameters:
    author: B. Kerler / seraj
    copyright: '2022'
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: signal_detector
    output_language: python
    title: Signal detector
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: out[1]
  states: {}
- name: fch
  id: variable
  parameters:
    value: out[0]
  states: {}
- name: fft_length
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: found
  id: variable_qtgui_label
  parameters:
    type: real
    value: fch
  states: {}
- name: founded_channel
  id: variable_qtgui_label
  parameters:
    type: real
    value: int(((float(fch)-freqmin)/(samp_rate/1e6))*fft_length)//1e6
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,0,1,1
    label: Frequency
    type: real
    value: 433.5e6
  states: {}
- name: freqmin
  id: variable
  parameters:
    value: (freq-(samp_rate/2))
  states: {}
- name: fun_prob_1
  id: variable_function_probe
  parameters:
    block_id: prob_sig_vec
    function_name: level
    poll_rate: '1'
    value: '0'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '49'
    value: '10'
  states: {}
- name: out
  id: variable
  parameters:
    value: epy_module_0.detect(fun_prob_1,samp_rate,thr,freq)
  states: {}
- name: pos
  id: variable
  parameters:
    value: int(((float(fch)-freqmin)/(samp_rate/1e6))*fft_length)//1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: thr
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: threshold
    rangeType: int
    start: '-100'
    step: '1'
    stop: '0'
    value: '-70'
  states: {}
- name: vec_length
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: thr
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '100'
    type: float
    vlen: vec_length
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(round(samp_rate/fft_length/1000))
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '-100'
    n: '10'
    vlen: vec_length
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: float
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, pos_init=2,pos_end=3,veclen=2048):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Vector Position Indicator',   # will show up in GRC\n            in_sig=[],\n            out_sig=[(np.float32,veclen)]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.pos_init = pos_init\n        self.pos_end = pos_end\n        self.veclen = veclen\n\n    def work(self, input_items, output_items):\n        try:\n            output_items[0][0][:] = np.zeros(self.veclen,dtype=np.float32)-1000\n            output_items[0][0][int(self.pos_init):int(self.pos_end)] = np.zeros(int(self.pos_end-self.pos_init),dtype=np.float32)+1000\n        except:\n            pass\n        for i in range(1,len(output_items[0])):\n            output_items[0][i][:] = output_items[0][0][:]\n        return len(output_items[0])\n\n"
    pos_end: pos+bw//2
    pos_init: pos-bw//2
    veclen: vec_length
  states: {}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      import numpy as np
      from gnuradio.qtgui.range import Range


      def avg_freq_pwr(data):
      	weighted_power = 0
      	sum_power = 0
      	for index, samples in enumerate(data):
      		weighted_power += index * float(samples)
      		sum_power += float(samples)
      	if len(data) <=0: 
      		return 0,0
      	else:
      		return weighted_power/float(sum_power)

      def estimate(spectrum,thr):
      	spectrum = np.append(spectrum,np.zeros(1))
      	length = len(spectrum)
      	channels = []
      	lnbins = []
      	bins = []
      	index = 0
      	while index < length:
      		if spectrum[index] > thr:
      			bins.append(spectrum[index])
      			index += 1
      		elif len(bins) > 3:
      			avg_freq = avg_freq_pwr(bins)
      			channels.append(index-len(bins)+avg_freq)
      			lnbins.append(len(bins))
      			index += 1
      			bins = []
      		else:
      			index += 1
      	return channels,lnbins

      channels = []
      lnbin = []
      ret = [0,0]
      channel_spacing = 0.0005

      def detect(data,fs,thr,freq):
      	global channels,lnbin,ret,channel_spacing
      	if isinstance(thr,Range):
      		# This fixes a weird qt range bug
        		thr = int(-70)
      	try:
      		spectrum = list(data)
      		spectrum = np.array([float(x) for x in spectrum])
      		channels,lnbin = np.array(estimate(spectrum,thr))
      		#print(channels,lnbin)
      		if len(channels) > 0:
      			resolution = fs/len(spectrum)
      			channels = (channels-len(spectrum)/2)*resolution
      			channels = np.round(channels/channel_spacing)*channel_spacing
      			print(channels,lnbin)
      			tmpf = []
      			for ch in channels:
      				tuned_channels = np.round((ch+freq)*1e6,3)
      				tmpf.append(tuned_channels)
      			channels = tmpf
      			ret = [channels[0]/1e6,lnbin[0]]
      		else:
      			ret = [0,0]
      	except Exception as err:
      		print(str(err))
      		pass
      	print(ret)
      	return ret
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_length
    forward: 'True'
    nthreads: '10'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_length)
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: gain
    freq0: freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: prob_sig_vec
  id: blocks_probe_signal_vx
  parameters:
    type: float
    vlen: vec_length
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,1
    type: complex
  states: {state: disabled}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,2
    nconnections: '3'
    vlen: vec_length
    width1: '2'
    width2: '2'
    width3: '2'
    x_axis_label: '"Freq in Mhz"'
    x_start: freq*1e6-(samp_rate/2)
    x_step: samp_rate/fft_length
    y_axis_label: '"PSD"'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_integrate_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_keep_one_in_n_0, '0', fft_vxx_0, '0']
- [blocks_nlog10_ff_0, '0', prob_sig_vec, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', qtgui_vector_sink_f_0, '1']
- [blocks_stream_to_vector_1, '0', blocks_keep_one_in_n_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [epy_block_0, '0', qtgui_vector_sink_f_0, '2']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [osmosdr_source_0, '0', blocks_stream_to_vector_1, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-949-gbf7f9fff
