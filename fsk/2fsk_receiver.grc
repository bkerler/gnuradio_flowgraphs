options:
  parameters:
    author: B. Kerler
    copyright: '2022'
    generate_options: qt_gui
    id: FSK
    output_language: python
    title: FSK Decoder
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: cf
  id: variable
  parameters:
    value: '444525000'
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '8'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: 40e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000.0'
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate/decimation/baudrate)
  states: {}
- name: tag_length
  id: variable
  parameters:
    value: '5'
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: cutoff
    gain: '1.0'
    samp_rate: samp_rate
    width: cutoff/3
    win: window.WIN_HAMMING
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: 443e6
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/msg
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/bjk/Projects/gnuradio_tutorial/fsk/data/2fsk.sigmf-data
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_1
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from binascii import hexlify

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, msglen=20, tag=[1,0,1,0,1,0,1,0], verbose=True):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Tag Debugger',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.byte]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.msglen = msglen*8
              self.tag = tag
              self.verbose = verbose

          def work(self, input_items, output_items):
              if len(input_items[0])>8:
                 curitems=len(input_items[0])
                 idx=0
                 pos=-1
                 for i in range(curitems): 
                    if input_items[0][i]==self.tag[idx]:
                       idx+=1
                    else:
                       idx=0
                    if idx==len(self.tag):
                       pos=i+1
                       break
                                 
                 if pos!=-1:
                    msglen=self.msglen
                    if curitems-pos>msglen:
                       if self.verbose:
                          print("Tag found")
                       o=0
                       data=input_items[0][pos:pos+msglen]
                       debug=""
                       for val in data:
                           debug+="%d" % val
                           output_items[0][o]=val
                           o+=1
                       if self.verbose:
                          print(debug)
                          if debug!='':
                             debug=int.to_bytes(int(debug,2),length=msglen//8,byteorder='big')
                             print(debug)
                       return o
                 else:
                     self.consume(0, curitems)
              return 0
    msglen: '18'
    tag: '[1,0,1,0,1,0,1,0]'
    verbose: 'True'
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: target_freq-cf
    decim: decimation
    samp_rate: samp_rate
    taps: taps
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: int(samp_rate/decimation)
    fc: cf
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    srate: int(samp_rate/decimation)
    tr_level: '0.2'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_agc3_xx_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [analog_agc3_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_1, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0, '0', analog_agc3_xx_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', epy_block_0, '0']
- [digital_symbol_sync_xx_1, '0', digital_binary_slicer_fb_0, '0']
- [epy_block_0, '0', blocks_pack_k_bits_bb_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-233-ga20232e9
