options:
  parameters:
    author: Lunny
    generate_options: qt_gui
    id: LoRa
    output_language: python
    title: LoRa-Tx
  states: {}

blocks:
- name: BW
  id: variable_qtgui_chooser
  parameters:
    label0: 125khz
    label1: 250khz
    label2: 500khz
    num_opts: '3'
    option0: '125000'
    option1: '250000'
    option2: '500000'
    type: int
    value: '250000'
  states: {}
- name: SF
  id: variable_qtgui_chooser
  parameters:
    label0: '7'
    label1: '8'
    label2: '9'
    num_opts: '3'
    option0: '7'
    option1: '8'
    option2: '9'
    orient: Qt.QHBoxLayout
    type: int
    value: '8'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: 450e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("hello world")
    period: '1000'
  states: {}
- name: lora_tx_0
  id: lora_tx
  parameters:
    bw: BW
    cr: '3'
    frame_zero_padd: '0'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    samp_rate: '2500000'
    sf: SF
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: BW
    center_freq0: rx_freq
    gain0: '0'
    len_tag_name: '"frame_len"'
    otw: sc16
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_message_strobe_0, strobe, lora_tx_0, in]
- [lora_tx_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
