options:
  parameters:
    author: B.Kerler
    category: '[GrCon22_CTF]'
    generate_options: qt_gui
    id: lora_RX
    output_language: python
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: int(125e3)
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 868.1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ./data/FINAL_HIGH_BAND_915000000Hz_2000000sps_50dB_2022_09_01_16_22_01.cfile
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: lora_lora_receiver_0
  id: lora_lora_receiver
  parameters:
    bandwidth: bw
    center_freq: '0'
    channel_list: '0'
    comment: |-
      Uses gr-lora
      https://github.com/rpp0/gr-lora
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: 2e6
    sf: '7'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 100e6
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', lora_lora_receiver_0, '0']
- [lora_lora_receiver_0, frames, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-233-ga20232e9
