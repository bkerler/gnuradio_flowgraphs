options:
  parameters:
    author: Lunny
    generate_options: qt_gui
    id: LoRa
    output_language: python
    title: LoRa-Rx
  states: {}

blocks:
- name: BW
  id: variable_qtgui_chooser
  parameters:
    label0: 125khz
    label1: 250khz
    label2: 500khz
    num_opts: '3'
    option0: '125000'
    option1: '250000'
    option2: '500000'
    type: int
    value: '250000'
  states: {}
- name: SF
  id: variable_qtgui_chooser
  parameters:
    label0: '7'
    label1: '8'
    label2: '9'
    num_opts: '3'
    option0: '7'
    option1: '8'
    option2: '9'
    orient: Qt.QHBoxLayout
    type: int
    value: '8'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: 490e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: BW
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: '2500000'
    sf: SF
    soft_decoding: 'True'
  states: {}
- name: lora_tx_0
  id: lora_tx
  parameters:
    bw: BW
    cr: '3'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    samp_rate: '2500000'
    sf: SF
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '12'
    port: '8888'
    send_eof: 'False'
    type: byte
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: rx_freq
    fftsize: '1024'
    showrf: 'True'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: rx_freq
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: rx_freq
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_message_strobe_0, strobe, lora_tx_0, in]
- [lora_rx_0, '0', network_udp_sink_0, '0']
- [lora_rx_0, out, blocks_message_debug_0, print]
- [lora_tx_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', lora_rx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
